
	ORG	0x0000

	NOP

	LDI	0x08
	XPAH	P1
LOOP0:	LDI	0x80
LOOP1:	ST	WORK
	ST	0(P1)
	RR
	ST	WORK
	DLY	0x10
	LD	WORK

	ANI	0xFE
	JZ	L1

	JMP	LOOP1

L1:	LDI	0x08
	XPAH	P1
	LDI	0x01
LOOP2:	ST	WORK
	ST	0(P1)
	LD	WORK
	CCL
	ADD	WORK
	ST	WORK
	DLY	0x10
	LD	WORK

	JZ	LOOP0

	JMP	LOOP2

WORK:	DB	0
